[aimspice]
[description]
116
high pass filter - first line always a comment
R1 0 IN 1K
C1 0 OUT 470N
Vmain IN OUT DC 5 sin(0 5 1k 0 0)

[dc]
1
Vmain
0
5
0.1
[tran]
1e-9
6e-3
X
X
0
[ana]
4 1
0
1 1
1 1 -6 6
2
v(in)
v(out)
[end]
